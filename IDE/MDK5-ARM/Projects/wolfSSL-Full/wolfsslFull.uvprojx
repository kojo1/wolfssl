# Keil uVision project wolfsslFull.uvprojx, settings and files
target STM32F207 Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wolfssl-Full
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE=25000000 MDK_CONF_full WOLFSSL_USER_SETTINGS
  c misc: --diag_suppress=1293
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: main.c shell.c time-CortexM3-4.c
  group Configuration
    ./RTE/wolfSSL/: user_settings.h
  group Dcumentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX 4.81.1, Compiler:I/O:File 1.4.0, Compiler:I/O:STDERR 1.4.0, Compiler:I/O:STDIN 1.4.0, Compiler:I/O:STDOUT 1.4.0, File System:CORE 6.10.0, File System:Drive:Memory Card 6.10.0, Network:CORE 7.7.0, Network:Interface:ETH 7.7.0, Network:Service:DNS Client 7.7.0, Network:Socket:BSD 7.7.0, Network:Socket:TCP 7.7.0, Network:Socket:UDP 7.7.0, CMSIS Driver:Ethernet MAC 2.8, CMSIS Driver:Ethernet PHY:ST802RT1 6.2.0, CMSIS Driver:MCI 2.6, Device:STM32Cube Framework:Classic 1.2.1, Device:STM32Cube HAL:Common 1.2.1, Device:STM32Cube HAL:Cortex 1.2.1, Device:STM32Cube HAL:DMA 1.2.1, Device:STM32Cube HAL:ETH 1.2.1, Device:STM32Cube HAL:GPIO 1.2.1, Device:STM32Cube HAL:RCC 1.2.1, Device:STM32Cube HAL:SRAM 1.2.1, Device:Startup 2.2.1, wolfSSL:wolfCrypt:Benchmark 3.14.0, wolfSSL:wolfCrypt:CORE 3.14.0, wolfSSL:wolfCrypt:Test 3.14.0, wolfSSL:wolfSSL:Core 3.14.0, wolfSSL:wolfSSL:SimpleClient 3.14.0, wolfSSL:wolfSSL:SimpleServer 3.14.0, wolfSSL:wolfSSL:echoClient 3.14.0, wolfSSL:wolfSSL:echoServer 3.14.0
